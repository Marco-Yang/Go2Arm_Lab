Commit message: solve the problems of unstable std

File: source/Go2Arm_Lab/Go2Arm_Lab/assets/go2_arx5/go2_arx5_finray_x85_z94.urdf (robot description, URDF)
Before this commit: robot go2_x5a, 39 links, 38 joints
Links:
- link link6: mass 0.44089 -> 0.902
